# Keil uVision project Demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3
  c include: U:\coe718\project\common\inc;U:\coe718\project\common\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  scatter file: .\Objects\Demo.sct
  group Source Group 1
    ./: GLCD_SPI_LPC1700.c Font_6x8_h.h Font_16x24_h.h GLCD.h LED.c LED.h LPC17xx.h menu.c KBD.c KBD.h adcuser.c usbcore.c usbdesc.c usbhw.c usbuser.c adcuser.h audio.h usb.h usbaudio.h usbcfg.h usbcore.h usbdesc.h usbhw.h usbreg.h usbuser.h usbdmain.c photoGallery.c gameTicTacToe.c gameMusicRhythm.c core_cm3.c system_LPC17xx.h mp3Player.c gameMenu.c gameBlackjack.c
  group Resources
    ./: Astronaut in Space.c Basketball.c MCB1700 Development Board.c gameboard.c symbol_O.c symbol_O_selected.c symbol_X.c symbol_X_selected.c audio_splashscreen.c
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS:Keil RTX 4.82.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
